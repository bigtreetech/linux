/dts-v1/;
/plugin/;

/ {
	
	fragment@0 {
		target = <&hdmi>;

		__overlay__ {
			status = "okay";
		};
	};

	fragment@1 {
		target = <&hdmi_in_vp0>;

		__overlay__ {
			status = "okay";
		};
	};

};